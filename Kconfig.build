## Kconfig.build
```kconfig
config DEBUG
	bool "Enable debug print"
	default false
	help
	  Enable debug print using print_dbg().
```
